# Keil uVision project SWM220_StdPeriph_Driver.uvproj, settings and files
target SWM220 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SWM220_stdperiph_lib +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM220_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM220_StdPeriph_Driver/: SWM220_adc.c SWM220_exti.c SWM220_gpio.c SWM220_i2c.c SWM220_pwm.c SWM220_timr.c SWM220_uart.c SWM220_wdt.c SWM220_flash.c SWM220_port.c SWM220_spi.c SWM220_dma.c SWM220_can.c SWM220_div.c SWM220_rtc.c SWM220_sleep.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM220.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM220.s
