# IAR project FreeRTOS.ewp, settings and files
configuration SWM220 (ARM, debug)
  General.OGChipSelectEditMenu: SWM220x8 Synwit SWM220x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\SWM220_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM220_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM220_StdPeriph_Driver\CSL\SWM220_StdPeriph_Driver; .\APP\FreeRTOS; .\APP\FreeRTOS\port_IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: APP/FreeRTOS
  OBJCOPY.OOCOutputFile: SWM2400_StdPeriph_Driver.srec
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CSL_StdPD
    ../../SWM220_StdPeriph_Driver/CSL/SWM220_StdPeriph_Driver/: SWM220_uart.c SWM220_can.c SWM220_port.c SWM220_dma.c SWM220_pwm.c SWM220_i2c.c SWM220_div.c SWM220_flash.c SWM220_wdt.c SWM220_gpio.c SWM220_spi.c SWM220_timr.c SWM220_adc.c SWM220_rtc.c SWM220_exti.c
  group CSL_CMSIS
    ../../SWM220_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM220.c
    ../../SWM220_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM220.s
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: tasks.c queue.c list.c
    ./APP/FreeRTOS/port_IAR/: port.c portasm.s
    ./APP/FreeRTOS/heap/: heap_1.c
