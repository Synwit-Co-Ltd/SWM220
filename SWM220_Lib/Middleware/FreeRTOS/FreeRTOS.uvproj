# Keil uVision project FreeRTOS.uvproj, settings and files
target SWM220 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: FreeRTOS
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2
  c include: ..\..\SWM220_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM220_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM220_StdPeriph_Driver\CSL\SWM220_StdPeriph_Driver;.\APP\FreeRTOS;.\APP\FreeRTOS\port_MDK
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c
    ./APP/FreeRTOS/heap/: heap_1.c
    ./APP/FreeRTOS/port_MDK/: port.c
  group CSL\StdPD
    ../../SWM220_StdPeriph_Driver/CSL/SWM220_StdPeriph_Driver/: SWM220_adc.c SWM220_exti.c SWM220_gpio.c SWM220_i2c.c SWM220_pwm.c SWM220_timr.c SWM220_uart.c SWM220_wdt.c SWM220_can.c SWM220_div.c SWM220_dma.c SWM220_flash.c SWM220_port.c SWM220_spi.c SWM220_rtc.c
  group CSL\CMSIS
    ../../SWM220_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM220.c
    ../../SWM220_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM220.s
