# Keil uVision project KeyLED.uvprojx, settings and files
target SWM220 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SWM220x8 Synwit
  pack: Synwit.SWM32_DFP.1.8.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: KeyLED
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\SWM220_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM220_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM220_StdPeriph_Driver\CSL\SWM220_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ../../SWM220_StdPeriph_Driver/CSL/SWM220_StdPeriph_Driver/: SWM220_adc.c SWM220_exti.c SWM220_gpio.c SWM220_i2c.c SWM220_pwm.c SWM220_timr.c SWM220_uart.c SWM220_wdt.c SWM220_can.c SWM220_div.c SWM220_dma.c SWM220_flash.c SWM220_port.c SWM220_spi.c SWM220_rtc.c
  group CSL\CMSIS
    ../../SWM220_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM220.c
    ../../SWM220_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM220.s
software components: CMSIS:CORE 5.3.0
